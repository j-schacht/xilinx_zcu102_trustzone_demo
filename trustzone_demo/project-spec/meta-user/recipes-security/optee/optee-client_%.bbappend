COMPATIBLE_MACHINE:zynqmp = "zynqmp-generic|xilinx-zcu102"
