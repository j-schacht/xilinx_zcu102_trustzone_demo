EXTRA_OEMAKE:append = " DEBUG=0"
EXTRA_OEMAKE:append = " LOG_LEVEL=LOG_LEVEL_NOTICE"
EXTRA_OEMAKE:append = " RESET_TO_BL31=1"
EXTRA_OEMAKE:append = " NEED_BL32=1"
EXTRA_OEMAKE:append = " SPD=opteed"
EXTRA_OEMAKE:append = " ZYNQMP_BL32_MEM_BASE=0x60000000"
EXTRA_OEMAKE:append = " ZYNQMP_BL32_MEM_SIZE=0x80000"
